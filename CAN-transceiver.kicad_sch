File: CAN-transceiver.kicad_sch (KiCad schematic)
At the start: 8 parts, among them IC2 TCAN1042DQ1

Commit message: modify, add comment
Other:
- note added: "IF THIS DEVICE IS NOT END-NODE, TERMINATION RESISTER IS FROM 1K OHM TO 2K OHM. YOU CAN CHOOSE WHITCH TERMINATION YOU MOUNT."
- note added: "SPLIT TERMINATION"
- note added: "TERMINATION"
- note added: "THE DEVICE IS ONLY USED IN NORMAL MODE."
- note added: "TRANSIENT VOLTAGE SUPPRESSION"
- moved on the sheet: C2, R7
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 101.6 63.5) (xy 101.6 66.04))
+  (wire (pts (xy 101.6 60.96) (xy 101.6 63.5))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 134.62 96.52) (xy 134.62 99.06))
+  (wire (pts (xy 134.62 99.06) (xy 134.62 101.6))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 101.6 53.34) (xy 101.6 55.88))
+  (wire (pts (xy 101.6 50.8) (xy 101.6 53.34))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 134.62 78.74) (xy 134.62 88.9))
+  (wire (pts (xy 134.62 78.74) (xy 134.62 91.44))
     (stroke (width 0) (type default))
   )
   (wire (pts (xy 182.88 82.55) (xy 180.34 82.55))
     (stroke (width 0) (type default))
+  )
+  (text "TRANSIENT VOLTAGE\nSUPPRESSION" (at 204.47 76.2 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "IF THIS DEVICE IS NOT END-NODE,\nTERMINATION RESISTER IS FROM 1K OHM TO 2K OHM.\nYOU CAN CHOOSE WHITCH TERMINATION YOU MOUNT."
+    (at 146.05 50.8 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "TERMINATION" (at 146.05 68.58 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "SPLIT\nTERMINATION" (at 160.02 68.58 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "THE DEVICE IS ONLY USED\nIN NORMAL MODE." (at 106.68 97.79 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (hierarchical_label "CANL" (shape bidirectional) (at 203.2 95.25 0) (fields_autoplaced)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "在庫" "" (at 152.4 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
   )
-  (symbol (lib_id "Device:C") (at 101.6 59.69 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C2" (at 105.41 58.42 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "C" (at 105.41 60.96 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 102.5652 63.5 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 101.6 59.69 0)
+  (symbol (lib_id "Device:C") (at 101.6 57.15 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C2" (at 105.41 55.88 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "C" (at 105.41 58.42 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 102.5652 60.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 101.6 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "在庫" "" (at 101.6 57.15 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 134.62 99.06 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR021" (at 134.62 105.41 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 134.62 104.14 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 134.62 99.06 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 134.62 99.06 0)
+  (symbol (lib_id "power:GND") (at 134.62 101.6 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR021" (at 134.62 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 134.62 106.68 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 134.62 101.6 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 134.62 101.6 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "power:+5V") (at 101.6 53.34 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR020" (at 101.6 57.15 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (at 101.6 48.26 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 101.6 53.34 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 101.6 53.34 0)
+  (symbol (lib_id "power:+5V") (at 101.6 50.8 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR020" (at 101.6 54.61 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+5V" (at 101.6 45.72 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 101.6 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 101.6 50.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "在庫" "" (at 176.53 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Datasheet" "~" (at 165.1 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "在庫" "" (at 165.1 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Device:R") (at 134.62 92.71 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "R7" (at 137.16 91.44 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "R" (at 137.16 93.98 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 132.842 92.71 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 134.62 92.71 0)
+  (symbol (lib_id "Device:R") (at 134.62 95.25 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R7" (at 137.16 93.98 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "R" (at 137.16 96.52 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 132.842 95.25 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 134.62 95.25 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "在庫" "" (at 134.62 95.25 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "発注先" "Digi-Key" (at 101.6 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "在庫" "" (at 101.6 78.74 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "在庫" "" (at 198.12 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "3")
     (pin "1")
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 101.6 66.04 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR019" (at 101.6 72.39 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 101.6 71.12 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 101.6 66.04 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 101.6 66.04 0)
+  (symbol (lib_id "power:GND") (at 101.6 63.5 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR019" (at 101.6 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 101.6 68.58 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 101.6 63.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 101.6 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "在庫" "" (at 165.1 76.2 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: modify labels
Connections:
- net +5V renamed VCC
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (hierarchical_label "VCC" (shape input) (at 99.06 83.82 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
   )
   (hierarchical_label "CANL" (shape bidirectional) (at 203.2 95.25 0) (fields_autoplaced)
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
+  (hierarchical_label "VCC" (shape input) (at 101.6 50.8 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+  )
   (symbol (lib_id "Device:R") (at 152.4 82.55 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         (path "/10edd9b6-c7a8-40f4-bfe3-c9724324d30f/a6f2c8d0-7153-435f-8690-872c30ac6e56"
           (reference "#PWR021") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "power:+5V") (at 101.6 50.8 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR020" (at 101.6 54.61 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (at 101.6 45.72 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 101.6 50.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 101.6 50.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "main-ECU-board"
-        (path "/10edd9b6-c7a8-40f4-bfe3-c9724324d30f/a6f2c8d0-7153-435f-8690-872c30ac6e56"
-          (reference "#PWR020") (unit 1)
         )
       )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "power:+5V") (at 99.06 83.82 90) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR018" (at 102.87 83.82 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (at 95.25 83.82 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 99.06 83.82 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 99.06 83.82 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "main-ECU-board"
-        (path "/10edd9b6-c7a8-40f4-bfe3-c9724324d30f/a6f2c8d0-7153-435f-8690-872c30ac6e56"
-          (reference "#PWR018") (unit 1)
-        )
-      )

Commit message: add sheet name, explain
Other:
- note added: "CAN TRANSCEIVER"
- note added: "IF NOT END-NODE, TERMINATION RESISTER IS FROM 1K OHM TO 2K OHM. IF END-NODE, TERMINATION IS NEEDED. CHOOSE NORMAL OR SPLIT TERMINATION."
- note removed: "IF THIS DEVICE IS NOT END-NODE, TERMINATION RESISTER IS FROM 1K OHM TO 2K OHM. YOU CAN CHOOSE WHITCH TERMINATION YOU MOUNT."
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
   )
-  (text "TRANSIENT VOLTAGE\nSUPPRESSION" (at 204.47 76.2 0)
+  (text "TRANSIENT VOLTAGE\nSUPPRESSION" (at 204.47 77.47 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (text "IF THIS DEVICE IS NOT END-NODE,\nTERMINATION RESISTER IS FROM 1K OHM TO 2K OHM.\nYOU CAN CHOOSE WHITCH TERMINATION YOU MOUNT."
-    (at 146.05 50.8 0)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
+  (text "IF NOT END-NODE,\nTERMINATION RESISTER IS FROM 1K OHM TO 2K OHM.\n\nIF END-NODE, TERMINATION IS NEEDED.\nCHOOSE NORMAL OR SPLIT TERMINATION."
+    (at 50.8 152.4 0)
+    (effects (font (size 2.54 2.54)) (justify left bottom))
   )
   (text "TERMINATION" (at 146.05 68.58 0)
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (text "CAN TRANSCEIVER" (at 190.5 177.8 0)
+    (effects (font (size 5.08 5.08)) (justify left bottom))
+  )
   (text "THE DEVICE IS ONLY USED\nIN NORMAL MODE." (at 106.68 97.79 0)
