File: MCU.kicad_sch (KiCad schematic)
At the start: 31 parts, among them IC1 R7FA4M1AB3CFM#AA0, J1 Conn_01x02_Pin, SW1 SW_MEC_5E, Y1 ABM8W-12.0000MHZ-8-K1Z-T3

Commit message: modify RESET button
Parts:
- removed SW1: SW_MEC_5E, Button_Switch_THT:SW_PUSH_6mm_H7.3mm, symbol Switch:SW_MEC_5E
- added SW1: SW_Push, Button_Switch_THT:SW_PUSH_6mm_H7.3mm, symbol Switch:SW_Push
Connections:
- net GND: now also SW1.1
- net ~{RESET}: now also SW1.2
Changed lines of the file:
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@@
   (junction (at 63.5 129.54) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 213.36 44.45) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 139.7 25.4) (diameter 0) (color 0 0 0 0)
   )
@@
   )
   (junction (at 260.35 44.45) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 198.12 46.99) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 93.98 25.4) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 198.12 46.99) (xy 198.12 49.53))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 93.98 25.4) (xy 119.38 25.4))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 198.12 46.99) (xy 200.66 46.99))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 96.52 152.4) (xy 88.9 152.4))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 213.36 46.99) (xy 210.82 46.99))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 154.94 116.84) (xy 152.4 116.84))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 213.36 44.45) (xy 210.82 44.45))
+  (wire (pts (xy 210.82 44.45) (xy 215.9 44.45))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 213.36 44.45) (xy 215.9 44.45))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 81.28 38.1) (xy 127 38.1))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 96.52 134.62) (xy 96.52 152.4))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 213.36 46.99) (xy 213.36 44.45))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 198.12 49.53 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR054" (at 198.12 55.88 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 198.12 54.61 0)
+  (symbol (lib_id "power:GND") (at 198.12 46.99 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR054" (at 198.12 53.34 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 198.12 52.07 0)
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 198.12 49.53 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 198.12 49.53 0)
+    (property "Footprint" "" (at 198.12 46.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 198.12 46.99 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         (path "/10edd9b6-c7a8-40f4-bfe3-c9724324d30f/e4f56512-cc65-4901-a795-709bf8d0df91"
           (reference "#PWR054") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "Switch:SW_MEC_5E") (at 205.74 46.99 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "SW1" (at 205.74 36.83 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "SW_MEC_5E" (at 205.74 39.37 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Button_Switch_THT:SW_PUSH_6mm_H7.3mm" (at 205.74 39.37 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "http://www.apem.com/int/index.php?controller=attachment&id_attachment=1371" (at 205.74 39.37 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "発注先" "Digi-Key" (at 205.74 46.99 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "在庫" "" (at 205.74 46.99 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (pin "3")
-    (pin "4")
-    (instances
-      (project "main-ECU-board"
-        (path "/10edd9b6-c7a8-40f4-bfe3-c9724324d30f/e4f56512-cc65-4901-a795-709bf8d0df91"
-          (reference "SW1") (unit 1)
         )
       )
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Switch:SW_Push") (at 205.74 44.45 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "SW1" (at 205.74 36.83 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "SW_Push" (at 205.74 39.37 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Button_Switch_THT:SW_PUSH_6mm_H7.3mm" (at 205.74 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 205.74 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "main-ECU-board"
+        (path "/10edd9b6-c7a8-40f4-bfe3-c9724324d30f/e4f56512-cc65-4901-a795-709bf8d0df91"
+          (reference "SW1") (unit 1)
+        )
+      )
