# Repository TUT-ProjectEV/main-ECU-board-2024

File README.md:

# main-ECU-board
- このブランチは作業記録を残すためだけに残してある

## Overview
- メインECUのハードウェア

## Requirement
### Development
- Kicad7.0
### Boards
- Arduino UNO R4
### Libraries
- Digi-Key Kicad Library
- Digi-Key Kicad Library にないもの
    - [ここ](https://componentsearchengine.com/) で検索してダウンロード
    - Library Loader を使用

## Usage
- Arduino UNO R4 互換(ブートローダのインストール必須)
    - 各種ヘッダーピン
    - R4 では使用できなかったピンも使用可能
- 車載対応
    - CANトランシーバ
    - ロードスイッチ(AIRなどへの12V供給)

## Features
- [ブートローダのインストール方法](./documents/install-boot-loader/)

## Reference
- [documents](./documents/) 内、使用ICの各種データシート

## Author
- [Takamura](https://github.com/ST04-tkmr)

## License
- Copyright (c) 2023 東京工科大学 ProjectEV [Released under the MIT license](./LICENSE)

## KiCad design main-ECU-board/main-ECU-board.kicad_pcb

Board: 4 copper layers, 100.0 x 65.0 mm, 118 parts (0 on the bottom side), 93 nets.

Parts:
C1, C2: 10u; C_0805_2012Metric
C3, C6, C10, C11, C12, C16, C17, C20, C21, C22, C23, C24, C25, C26: 0.1u; C_0603_1608Metric
C4: 33n; C_0402_1005Metric
C5: 47u; CP_Elec_6.3x5.4_Nichicon
C7: 47p; C_0402_1005Metric
C8, C9: 22u; C_0805_2012Metric
C13, C14: 8p; C_0402_1005Metric
C15, C19: 4.7u; C_0805_2012Metric
C18: 1u; C_0603_1608Metric
D1: UDZVTE-175.1B; D_SOD-323_HandSoldering
D2: CUHS20S30; CUHS20S40H3F
D3: LED_R; LED_0603_1608Metric
D4: NUP2105L; SOT-23
D5, D6, D7: LED_G; LED_0603_1608Metric
D8: PRTR5V0U2X_215; TO-253-4
D9, D10: RB160M-30TR; D_SOD-123F
F1: ERB-RD1R50X; Fuse_0402_1005Metric
FB1, FB2: BLM18PG471SN1D; 0603
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J2: USB_C_Receptacle; 5077CR-16-SMC2-BK-TR
J3, J4, J5, J6, J14: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J7, J8, J9: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10, J11, J12: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J13, J16: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J15: Conn_02x05_Odd_Even; PinHeader_2x05_P1.00mm_Vertical
L1: 22u; L_MGAH0603
Q1: AO3401A; SOT-23
R1: 430k; R_0603_1608Metric
R2: 51.1k; R_0603_1608Metric
R3, R8, R16, R20, R23, R24, R25, R29, R30, R36, R37, R38, R39, R41, R42, R43, R46, R47, R48, R50, R51, R52, R53, R54: 15k; R_0603_1608Metric
R4: 0; R_0603_1608Metric
R5: 52.3k; R_0603_1608Metric
R6: 10k; R_0603_1608Metric
R7, R19, R21, R22: 300; R_0603_1608Metric
R9, R40, R44, R45, R49: 1k; R_0603_1608Metric
R10, R11: 60.4; R_0603_1608Metric
R12, R13, R14, R15: 5.1k; R_0603_1608Metric
R17, R26, R27, R28, R35: 100k; R_0603_1608Metric
R18: 13.7k; R_0603_1608Metric
R31, R32, R33, R34: 3k; R_0603_1608Metric
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
U1: TPS62933; SOT-583-8
U2: TCAN1042DQ1; SOIC127P600X175-8N
U3: R7FA4M1AB3CFM#AA0; QFP50P1200X1200X170-64N
U4, U5: TPS2H160AQPWPRQ1; SOP65P640X120-17N
Y1: ABM8W-12.0000MHZ-8-K1Z-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
2: J8.2, R30.1, U3.43 (P105)
3: J7.2, R29.1, U3.44 (P104)
4: U2.1 (TXD), U3.45 (P103)
5: U2.4 (RXD), U3.46 (P102)
6: R41.1, U3.42 (P106)
7: R42.1, U3.41 (P107)
8: R47.1, U3.28 (P304)
9: R46.1, U3.29 (P303)
+3V3: C17.2, C19.2, U3.4 (VBATT), U3.20 (VCC_USB)
+5V: C7.1, C8.1, C9.1, C10.1, C11.1, C20.1, C21.1, C22.1, D2.1 (K), D3.2 (A), D5.2 (A), D6.2 (A), FB1.1, J3.1, J4.1, J5.1, J7.1, J8.1, J10.1, J12.1, J13.1, J14.1, J15.1, J16.1, L1.2, R5.2, R12.1, R13.2, R16.2, R17.2, R20.1, R23.1, R31.1, R32.1, R33.1, R34.1, R38.1, R39.1, U2.3 (VCC), U3.11 (VCC_1), U3.21 (VCC_USB_LDO), U3.39 (VCC_2)
+12V: C1.1, C2.1, C3.1, C5.1, D1.1 (K), Q1.2 (S), R1.1, U1.3 (VIN)
+BATT: F1.1, J6.1
/MCU/AREF: FB2.1, R12.2
A0: C23.1, J3.2, R26.1, U3.53 (P014)
A1: C24.1, J4.2, R27.1, U3.64 (P000)
A2: C25.1, J5.2, R28.1, U3.63 (P001)
A3: C26.1, J14.2, R35.1, U3.62 (P002)
AIR_M_OUT: J11.4, U5.11 (OUT2_1), U5.12 (OUT2_2)
AIR_P_OUT: J11.3, U5.15 (OUT1_1), U5.16 (OUT1_2)
BOOT: J1.1, R23.2, U3.26 (P201/MD)
CANH: D4.2 (K), J9.1, R9.1, R10.1, U2.7 (CANH)
CANL: D4.1 (K), J9.2, R9.2, R11.2, U2.6 (CANL)
CC1: J2.A5 (CC1), R24.1
CC2: J2.B5 (CC2), R25.1
CS/10: J13.5, U3.37 (P112)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C16.2, C17.1, C18.2, C19.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, D4.3 (A), D8.1 (GND), D9.1 (K), D10.1 (K), J1.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.3, J4.3, J5.3, J6.3, J10.4, J12.4, J13.6, J14.3, J15.3, J15.5, J15.9, J16.6, R2.2, R3.2, R6.2, R7.2, R8.2, R15.1, R18.1, R22.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R35.2, R40.2, R44.2, R45.2, R49.2, R54.2, SW1.1, U1.4 (GND), U2.2 (GND), U3.8 (VSS_1), U3.17 (VSS_USB), U3.40 (VSS_2), U3.57 (AVSS0), U4.9 (THER), U5.9 (THER), Y1.2, Y1.4
MISO/12: J13.3, R32.2, U3.35 (P110/TDI)
MOSI/11: J13.4, R34.2, U3.34 (P109/TDO/SWO)
unnamed: C6.1, R4.2
unnamed: C12.1, R10.2, R11.1
unnamed: D1.2 (A), Q1.1 (G), R3.1
unnamed: D3.1 (K), R7.1
unnamed: D5.1 (K), R19.1
unnamed: D6.1 (K), R21.1
unnamed: D7.1 (K), R22.1
unnamed: D9.2 (A), R44.1, U4.8 (GND), U4.17 (EP)
unnamed: D10.2 (A), R49.1, U5.8 (GND), U5.17 (EP)
unnamed: F1.2, Q1.3 (D)
unnamed: R14.1, R15.2
unnamed: R50.2, R51.1
unnamed: R51.2, R52.1
unnamed: R53.2, R54.1
unnamed: R4.1, U1.6 (BST)
unnamed: R1.2, R2.1, U1.2 (EN)
unnamed: C7.2, R5.1, R6.1, U1.8 (FB)
unnamed: C4.1, U1.7 (SS)
unnamed: C6.2, L1.1, U1.5 (SW)
unnamed: R8.1, U2.8 (STB)
unnamed: C16.1, FB1.2, U3.56 (AVCC0)
unnamed: C18.1, FB2.2, U3.59 (P010/VREFH0)
unnamed: R16.1, U3.27 (P200)
unnamed: C14.2, U3.10 (P212/EXTAL), Y1.1
unnamed: C13.2, U3.9 (P213/XTAL), Y1.3
unnamed: R13.1, R14.2, U3.16 (P407)
unnamed: R17.1, R18.2, U3.49 (P500)
unnamed: C15.2, U3.5 (VCL)
unnamed: R40.1, U4.7 (CL)
unnamed: R43.2, U4.3 (DIAG_EN)
unnamed: R41.2, U4.1 (IN1)
unnamed: R42.2, U4.2 (IN2)
unnamed: R36.1, R38.2, U4.5 (~ST1), U5.5 (~ST1)
unnamed: R37.2, R39.2, U4.6 (~ST2), U5.6 (~ST2)
unnamed: R45.1, U5.7 (CL)
unnamed: R48.2, U5.3 (DIAG_EN)
unnamed: R46.2, U5.1 (IN1)
unnamed: R47.2, U5.2 (IN2)
P003_OPT_I/O: J16.2, U3.61 (P003)
P004_OPT_I/O: J16.3, U3.60 (P004)
P012: R19.2, U3.55 (P012/VREFH)
P013: R21.2, U3.54 (P013/VREFL)
P113_OPT_I/O: J16.4, U3.38 (P113)
P204_SHUTDOWN_DETECT: R52.2, R53.1, U3.24 (P204)
P205_OPT_I/O: J16.5, U3.23 (P205)
P408_STATUS_2: R37.1, U3.15 (P408)
P409_STATUS_1: R36.2, U3.14 (P409)
P410_DIAG_EN_2: R48.1, U3.13 (P410)
P411_DIAG_EN_1: R43.1, U3.12 (P411)
PRECHARGE_OUT: J11.2, U4.11 (OUT2_1), U4.12 (OUT2_2)
READY_TO_DRIVE_LED_OUT: J11.1, U4.15 (OUT1_1), U4.16 (OUT1_2)
RX/0: J10.3, U3.31 (P301)
SCI_RX: J15.7, U3.51 (P502)
SCI_TX: J15.8, U3.50 (P501)
SCK/13: D7.2 (A), J13.2, U3.36 (P111)
SCL/A5: J12.2, R31.2, U3.48 (P100)
SDA/A4: J12.3, R33.2, U3.47 (P101)
SHUTDOWN_CIRCUIT: J6.2, R50.1, U4.13 (VS_1), U4.14 (VS_2), U5.13 (VS_1), U5.14 (VS_2)
SWCLK: J15.4, U3.32 (P300/TCK/SWCLK)
SWDIO: J15.2, U3.33 (P108/TMS/SWDIO)
TX/1: J10.2, U3.30 (P302)
USB_D_M: D8.2 (I/O1), J2.A7 (D-), J2.B7 (D-), U3.18 (P915/USB_DM)
USB_D_P: D8.3 (I/O2), J2.A6 (D+), J2.B6 (D+), U3.19 (P914/USB_DP)
VBUS: D2.2 (A), D8.4 (VCC), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
~RESET: J15.10, R20.2, SW1.2, U3.25 (RES)

## Commit log

2023-10-23 Create a project
2023-10-30 create .github, add issue templates
2023-10-30 add Arduino UNO pin
2023-10-30 add MCU, type-C
2023-10-30 add parts
2023-10-30 add part
2023-10-30 発注先ラベル追加
2023-11-02 usb周り修正
2023-11-03 add CAN Transceiver Circuit
2023-11-03 add Power Circuit
2023-11-03 add Power, CAN Transceiver and modify
2023-11-04 modify, add comment
2023-11-04 almost complete
    回路図はほぼ完成、コメント記載済み、回路定数未決定
2023-11-04 add usb, header
    add usb connector, arduino header
2023-11-04 almost completed power, can, mcu
2023-11-05 modify
    add label
2023-11-05 modify labels
2023-11-05 add connectors
    accel, brake, air, ready to drive, etc...
2023-11-05 mofify
2023-11-05 add fuse, modify
2023-11-05 add, modify
2023-11-06 add connectors, modify, adjust
2023-11-06 add load switch for relay and led drive
2023-11-06 modify
2023-11-06 add circuit, modify
    add load switch, add connector, connect blocks, etc...
2023-11-07 add 12-5 level shifter
2023-11-07 modify, add I/O port
2023-11-07 modify, add module
    信号の向きの修正、レベルシフター追加、ポート追加
2023-11-07 add datasheet of RA4M1
2023-11-07 add user manual of RA4M1
2023-11-07 add Arduino UNO R4 schematic
2023-11-09 modify, add connector
    I2C, debug interface, 位置修正
2023-11-09 add translated datasheet
2023-11-09 modify signal name
2023-11-09 modify, add port
    add optional port, debug interface
2023-11-09 modify, add parts
2023-11-09 add sheet name, explain
2023-11-09 add datasheets
2023-11-09 create how to install boot loader
2023-11-09 modify README add Libraries, Usage, Features, Reference
2023-11-12 add connector, modify
    add SPI connector, modification, add pullup, modify shield connection with GND
2023-11-13 add reference
2023-11-13 modify symbol number, constant
2023-11-13 add Issue template
2023-11-13 modify symbol number
2023-11-13 decide constant
2023-11-16 decide constant, modify
2023-11-16 re-annotate
2023-11-16 modify constant
2023-11-16 modify constant, add 発注先 and footprint
2023-11-16 add and modify 発注先 and footprint
2023-11-16 modify constant, footprint
2023-11-16 add footprint
2023-11-23 コネクタフットプリント割当
2023-11-23 add footprints to C
2023-11-25 add tolerance
2023-11-26 回路図からフットプリント追加、Arduinoピン修正
2023-11-26 modify SPI connector pin assign
2023-11-26 modify RESET button
2023-11-26 機能ごとにざっくり部品配置
2023-11-26 自宅UbuntuPCにて保存
2023-11-27 add defined pattern width and via size
2023-11-27 部品配置更新
    コネクタ、CANあたりはおおよそできた
2023-11-27 逆接保護まわり修正
2023-11-28 modify footprint path and 3dmodel path
2023-11-28 修正、電源回路のおおよその配置
2023-11-28 modify L1
    value, footprint, 発注先
2023-11-28 電源回路の配置、フットプリント修正
2023-11-28 電源回路配置修正、AIRなどの駆動回路修正
2023-11-28 サーマルパッドの接続先変更
2023-11-28 部品配置おおよそ終了
2023-11-29 電源、ハイサイドスイッチまわり配置修正
2023-11-29 電源付近修正
2023-11-29 電源と電源コネクタ、type-cコネクタまわりの配置修正
2023-11-29 原点の設定、修正
    パッド、D8の位置
2023-11-30 固定用穴追加
2023-11-30 電源仮配線、デザインルール設定
2023-11-30 DCDC付近電源パターン作成
2023-12-03 電源配線
2023-12-03 modify design rules
2023-12-03 電源とAIRなどの電流大きめのパターン
2023-12-04 RESETプルアップ位置修正、シルク位置修正
2023-12-04 電源配線、シルク位置修正
2023-12-04 パターン一部引いた
    電源、アナログ、優先順位高そうなところ
2023-12-05 Arduino header削除、ピンアサイン修正
    ハイサイドスイッチ信号、UARTなど
    Arduino互換ピンはXHで出す
    回路図一部修正
    パターン削除、部品配置
2023-12-05 配置修正、電源パターン
2023-12-06 デバッグインターフェースのフットプリント変更
    2.54mm pitch -> 1.00 mm pitch
2023-12-06 ヒューズ変更、コネクタ配置変更、CANまわり配置修正
2023-12-06 シルク修正
2023-12-07 電源パターン修正
    合わせてその他部品配置の修正、コネクタ配置修正
2023-12-07 ピンアサイン修正
    OPTIONAL I/O の電源ピン
2023-12-07 部品配置修正、基板外形サイズ変更
2023-12-07 シルク修正、部品配置修正、電源パターン修正
2023-12-08 電源パターン追加修正、電源部品配置修正
2023-12-09 水晶振動子のGND接続方法修正
2023-12-09 電源、クロック、一部部品配置修正
2023-12-09 アナログ系配置修正、リセットとブートのプルアップ位置修正
    アナログ電源のFBをレギュレータの近くに配置
2023-12-10 電源、マイコン周辺パターン作成
2023-12-11 シャットダウン回路のパターン、その他微修正
2023-12-14 debug, OPT I/O, UART, GNDベタ以外のパターン完了
    チェック未完了
2023-12-15 GNDベタ以外完了
2023-12-15 シャットダウン検知をMOSFETから分圧回路に変更、リファレンス指定子"IC?"を"U?"に変更
2023-12-16 GNDベタ、その他微修正、デザインルール修正
    GNDベタの細かいところのビアは未完了
    その他修正：シルク位置、配線位置など
    デザインルール：穴と穴のクリアランス
2023-12-17 GNDビアの追加
2023-12-21 GNDビア追加、修正
2023-12-21 1ピン識別子追加、シルク修正
2023-12-21 シルク修正
    D8のシルク修正、1ピン識別子追加
2023-12-21 export 3D-model
2023-12-28 add ignore file
    .DS_Store
2023-12-28 リポジトリ内のディレクトリ構造を変更
    Kicadプロジェクトのフォルダをリポジトリ内に作成する
    Kicadによって作成されるファイル以外はリポジトリ直下に配置（documentsフォルダ、READMEファイル）
2023-12-28 リポジトリ内のディレクトリ構造を変更
    Arduino-UNO-R4ブランチより移行
    Kicadプロジェクトのフォルダをリポジトリ内に作成する
    Kicadによって作成されるファイル以外はリポジトリ直下に配置（documentsフォルダ、READMEファイル）
2023-12-28 作業記録保存のため、ブランチを残しておく
    feature/v1.0へ、プロジェクト移行
    以後の作業はfeature/v1.0にて
